# IAR project da14580_template.ewp, settings and files
configuration DA14580_Release (ARM, debug)
  General.OGChipSelectEditMenu: APOLLO2_1024 AmbiqMicro APOLLO2_1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: APOLLO2_1024=1; APOLLO2_1024=1
  ICCARM.CCIncludePath2: ..\..\common; ..\..\example\source; ..\..\example\source\config; ..\..\library; ..\..\library\highlevel; ..\..\library\middleware; ..\..\library\lowlevel
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: da14580_template.srec
  ILINK.IlinkOutputFile: da14580_template.out
  ILINK.IlinkIcfFile: config\DA14580_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DA14580_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ILINK.IlinkIcfFile: config\DA14580_ram.icf
  group (top)
    ../../: Readme.txt
  group common
    ../../common/: system_ARMCM0.c
  group source
    ../source/: main.c
    ./: startup_da14580.s
