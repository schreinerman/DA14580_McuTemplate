# Keil uVision project da14580_template.uvprojx, settings and files
target DA14580_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: da14580_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\common;..\..\example\source;..\..\example\source\config;..\..\library;..\..\library\lowlevel;..\..\library\middleware;..\..\library\highlevel
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  group common
    ../../common/: system_ARMCM0.c
  group source
    ../source/: main.c
    ../../: Readme.txt
    ./: startup_da14580.s
target DA14580_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.2.0
  cpu: as above
  output: da14580_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO2_1024=1 APOLLO2_1024=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
